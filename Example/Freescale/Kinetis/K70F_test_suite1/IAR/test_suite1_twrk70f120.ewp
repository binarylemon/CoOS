# IAR project test_suite1_twrk70f120.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\..\BSPLIB\inc; ..\..\BSPLIB\src; ..\..\cmsis; ..\..\cmsis\include; ..\..\..\..\..\CoOS\portable; ..\..\..\..\..\CoOS\kernel; ..\..\..\..\..\Test\suite1\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: 1MB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: lwip_twrk60n512.srec
  group (top)
    ../: AppConfig.h main.c OsConfig.h
    ./: isr.h low_init.c syscalls.c vectors.c vectors.h
  group BSPLIB/uart
    ../../BSPLIB/src/: mk_uart.c
    ../../BSPLIB/inc/: mk_uart.h
  group cmsis
    ../../cmsis/: system_MK70F.c system_MK70F.h
  group CoOS
    ../../../../../CoOS/kernel/: coocox.h CoOS.h core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c OsCore.h OsError.h OsEvent.h OsFlag.h OsKernelHeap.h OsMM.h OsMutex.h OsQueue.h OsServiceReq.h OsTask.h OsTime.h OsTimer.h queue.c sem.c serviceReq.c task.c time.c timer.c utility.c utility.h
  group CoOS/port
    ../../../../../CoOS/portable/: arch.c OsArch.h
    ../../../../../CoOS/portable/IAR/: portForM4.asm
  group suite1
    ../../../../../Test/suite1/src/: flagTest.c kHeapTest.c mboxTest.c mmTset.c mutexTest.c queueExTest.c queueTest.c semTest.c taskTest.c test.c test.h timerTest.c timeTest.c
