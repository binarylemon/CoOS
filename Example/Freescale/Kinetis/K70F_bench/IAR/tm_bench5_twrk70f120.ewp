# IAR project tm_bench5_twrk70f120.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; TM_BENCH=5
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..; ..\..\BSPLIB\inc; ..\..\BSPLIB\src; ..\..\cmsis; ..\..\cmsis\include; ..\..\..\..\..\CoOS\portable; ..\..\..\..\..\CoOS\kernel
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: tm_bench5.out
  ILINK.IlinkIcfFile: 1MB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TM_BENCH=5
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: lwip_twrk60n512.srec
  group (top)
    ../: AppConfig.h OsConfig.h
    ./: isr.h low_init.c syscalls.c vectors.c vectors.h
  group BSPLIB/uart
    ../../BSPLIB/src/: mk_uart.c
    ../../BSPLIB/inc/: mk_uart.h
  group cmsis
    ../../cmsis/: system_MK70F.c system_MK70F.h
  group CoOS
    ../../../../../CoOS/kernel/: coocox.h CoOS.h core.c event.c flag.c hook.c kernelHeap.c mbox.c mm.c mutex.c OsCore.h OsError.h OsEvent.h OsFlag.h OsKernelHeap.h OsMM.h OsMutex.h OsQueue.h OsServiceReq.h OsTask.h OsTime.h OsTimer.h queue.c sem.c serviceReq.c task.c time.c timer.c utility.c utility.h
  group CoOS/port
    ../../../../../CoOS/portable/: arch.c OsArch.h
    ../../../../../CoOS/portable/IAR/: portForM4.asm
  group tm_bench
    ../../../../../Components/Thread_Metric/: tm_interrupt_preemption_processing_test.c tm_porting_layer_coos.c
